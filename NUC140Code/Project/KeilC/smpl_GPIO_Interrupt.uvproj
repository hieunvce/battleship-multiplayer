# Keil uVision project smpl_GPIO_Interrupt.uvproj, settings and files
target smpl_GPIO_Interrupt (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC140LE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_GPIO_Interrupt +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\;..\..\CMSIS\CM0\CoreSupport;..\..\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;..\..\Include;..\..\Include\Driver
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
  group Source files
    ./: smpl_GPIO_Interrupt.c
  group Library files
    ../../Src/Driver/: DrvGPIO.c DrvSYS.c DrvUART.c
